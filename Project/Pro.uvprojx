# Keil uVision project Pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4
  c misc: --cpp
  c include: ..\Libraries\inc;..\Libraries\src;..\CIMIS;..\Startup;..\User;..\User\Code_C\inc;..\User\Code_C\src;..\User\Code_C++\inc;..\User\Code_C++\src;..\User\DSP\Include;..\User\DSP\FastMathFunctions
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../User/: main.c
    ../User/Code_C/src/: Scheduler.c Communication.c FlyControl.c Posotion.c Attitude.c Math_User.c SysState.c
  group Code_C++
    ../User/Code_C++/src/: Target.cpp I2C_Soft.cpp Filter.cpp PID.cpp
  group Driver
    ../User/Code_C/src/: Time.c Led.c Motor.c MPU6050.c SBUS.c NRF24L01.c Battery.c ADS1118.c USART1.c HMC5883.c Buzzer.c Ultra.c USART.c MS5611_SPI.c RTK.c ANO_DT.c
  group Startup
    ../Startup/: startup_stm32f40xx.s
  group CMSIS
    ../CIMIS/: system_stm32f4xx.c
  group Library
    ../User/: stm32f4xx_it.c
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_flash.c
  group DSP
    ../User/DSP/CommonTables/: arm_common_tables.c
    ../User/DSP/FastMathFunctions/: arm_sin_f32.c arm_cos_f32.c
